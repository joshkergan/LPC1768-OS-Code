# Keil uVision project OS_project.uvproj, settings and files
target Ram Target (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: OS_project
  c flags: Optim=1
  c define: DEBUG_0 _DEBUG_HOTKEYS K_MSG_ENV
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s
  group System Files
    ./src/: HAL.c main_svc.c printf.c string.c timer.c uart_irq.c uart_polling.c system_LPC17xx.c
  group Kernel Code
    ./src/: clock.c crt.c k_memory.c k_message.c k_priority_queue.c k_process.c k_rtx_init.c kcd.c null_process.c set_priority.c
  group User Code
    ./src/: stress_test.c usr_proc.c
target Sim Target (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: OS_project
  c flags: Optim=1
  c define: DEBUG_0 _DEBUG_HOTKEYS K_MSG_ENV SIMULATOR
  asm define: DEBUG_0 _DEBUG_HOTKEYS K_MSG_ENV
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
