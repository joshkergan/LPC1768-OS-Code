# Keil uVision project context_switching.uvproj, settings and files
target Context Switching SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: context_switching
  c flags: Optim=1
  c define: K_MSG_ENV _DEBUG_HOTKEYS DEBUG_0
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000000
  memory RVCT9: RAM 0x10004000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Code
    ./src/: system_LPC17xx.c uart_polling.c printf.c main_svc.c uart_irq.c timer.c string.c
  group RTX Kernel Code
    ./src/: HAL.c k_rtx_init.c k_memory.c k_process.c k_priority_queue.c null_process.c kcd.c crt.c k_message.c clock.c
  group User Code
    ./src/: usr_proc.c
  group Documentation
    ./: Abstract.txt
